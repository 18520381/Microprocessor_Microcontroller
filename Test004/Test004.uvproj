# Keil uVision project Test004.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Test004
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 18520381_Chapter2_Part5_1.asm 18520381_Chapter2_Part5_2.asm 18520381_Chapter2_Part5_3.asm 18520381_Chapter2_Part5_4.asm
