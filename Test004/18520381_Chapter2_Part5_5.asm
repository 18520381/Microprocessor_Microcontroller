	ORG 0
	LJMP MAIN
	LJMP EX0ISR
	ORG 000BH
	LJMP TOISR
	ORG 001BH
	LJMP T1ISR
	ORG 0030H
MAIN:	SETB IT0
		MOV TMOD, #11H
		MOV IE, #81H
		SJMP $
EX0ISR:	MOV R7, #200
		SETB TF0
		SETB TF1
		SETB ET0
		SETB ET1
		RETI
TOISR:	CLR TR0
		DJNZ R7, SKIP
		CLR ET0
		LJMP EXIT
		MOV TH0, #HIGH(-50000)
		MOV TL0, #LOW(-50000)
		SETB TR0
EXIT:	RETI
T1ISR:	CLR TR1
		MOV TH1, #HIGH(-1250)
		MOV TH1, #LOW(-1250)
		CPL P1.1
		SETB TR1
		RETI
	END